# Keil uVision project IOOutput.uvproj, settings and files
target Output (MCS-51)
  device: STC89C52RC STC89C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: IOOutput +hex
  c flags: Optimize=8 SizeSpeed=1
  group platform
    ./: STARTUP.A51
  group main
    ./: main.c
